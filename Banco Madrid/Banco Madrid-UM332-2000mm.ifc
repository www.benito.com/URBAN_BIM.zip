Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T12:31:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 12:31:07 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\fc902aa1-24cd-4598-b926-14f46f50c2d8\5296999c-1607-47a2-aed5-08a62876d7f5\ifc * Database version: 5507 * Database creation date: Fri Mar 10 12:31:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 12:31:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 12:31:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Madrid:Banco Madrid-UM332-2000mm, Banco Madrid:Banco Madrid-UM332-2000mm:567305
In: Level 1
Type - Material: Wood
Type - PRODUCT_PROPERTIES - 02 Material Pies: Acero Ferrus; 02 Material Tablones: Madera trópical; 03 Dimension_A: 2 m; 03 Dimension_H: 0.75 m; 03 Dimension_H1: 0.388 m; 03 Dimension_B: 0.654 m; 04 Descripción: Banco fabricado con pies y refuerzo central de pletina de acero de 50 x 8 mm (UM332: 50 x 16 mm); 05 Información_Adicional: Anclaje recomendado: Mediante tornillos de fijación M10 según superficie y proyecto; 06 Referencia: UM332; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/madrid--UM330.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM330; 09 Fabricante: BENITO URBAN SL
Material: Wood, Galvanized Steel
PRODUCT_PROPERTIES - 01 Producto: Banco Madrid: Banco Madrid-UM332-2000mm
