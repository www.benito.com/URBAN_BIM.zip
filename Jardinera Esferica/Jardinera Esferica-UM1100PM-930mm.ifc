Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-16T09:23:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 16 09:23:37 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\56256061-0387-4b93-adbf-ac73e904bdcc\ca6776ae-c0c7-4cd5-b5c5-0437cf60ae91\ifc * Database version: 5507 * Database creation date: Thu Mar 16 09:23:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 16 09:23:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 16 09:23:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Esferica:Jardinera Esferica-UM1100PM-930mm, Jardinera Esferica:Jardinera Esferica-UM1100PM-930mm:702656
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.93 m; 03 Dimension_H: 0.405 m; 04 Descripción: Jardinera fabricada en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM1100PM; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/esferica--UM1100PM.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1100PM; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Esferica: Jardinera Esferica-UM1100PM-930mm
