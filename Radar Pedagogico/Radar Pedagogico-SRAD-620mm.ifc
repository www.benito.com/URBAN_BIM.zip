Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:08:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:08:16 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\8dc87799-8932-4998-9700-43e6f08baabd\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:08:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:08:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:08:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Radar Pedagogico:Radar Pedagogico-SRAD-620mm, Radar Pedagogico:Radar Pedagogico-SRAD-620mm:968758
In: Level 1
Type - Material: Glass(1), Glass (16), Number (2), Plastic (2)
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0.62 m; 03 Dimension_B: 0.62 m; 03 Dimension_C: 0.04 m; 03 Dimension_D: 0.455 m; 04 Descripción: El radar pedagógico de BENITO sirve para disuadir a los usuarios que circulan por encima del límite establecido, mostrándoles que lo están infringiendo. Está demostrado que a pesar de no ser un radar sancionador, su efectividad es muy buena. Además es una medida menos agresiva para los vecinos que otros sistemas de reducción de velocidad como son las bandas reductoras y otros obstáculos que suelen suponer un inconveniente para los usuarios más recurrentes.; 06 Referencia: SRAD; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/reductores-de-velocidad/radar-pedagogico--SRAD.html#:~:text=El%20radar%20pedag%C3%B3gico%20de%20BENITO,su%20efectividad%20es%20muy%20buena.; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-SRAD; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Radar Pedagogico: Radar Pedagogico-SRAD-620mm
