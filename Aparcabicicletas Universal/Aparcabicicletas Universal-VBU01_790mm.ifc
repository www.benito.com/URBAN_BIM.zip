Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-20T21:32:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 20 21:32:54 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\57a434c2-c1e7-4c9d-878a-ea03f0f1ead9\7560f214-1d6a-446a-ae75-62acce92de6a\ifc * Database version: 5507 * Database creation date: Mon Feb 20 21:32:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 20 21:32:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 20 21:32:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Aparcabicicletas Universal:Aparcabicicletas Universal-VBU01-790mm, Aparcabicicletas Universal:Aparcabicicletas Universal-VBU01-790mm:275949
In: Level 1
Type - Material: <Unnamed>
Type - PRODUCT_PROPERTIES - 02 Material: Acero galvanizado; 03 Dimension_A: 0.79 m; 03 Dimension_H: 0.955 m; 03 Dimension_H1: 0.75 m; 03 Dimension_B: 0.09 m; 04 Descripción: Aparcabicis fabricado en acero galvanizado. Disponible en acero inoxidable (VBU01I); 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón.; 06 Referencia: VBU01; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/aparcabicicletas/universal--VBU01.html?gclid=CjwKCAiA0cyfBhBREiwAAtStHB-7aAZVcL6PAJfk-BIibeUp8Ke2zWo-hqdI10051RzDk-NqIeo_LhoCxE4QAvD_BwE; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBU01; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Aparcabicicletas Universal: Aparcabicicletas Universal-VBU01-790mm
