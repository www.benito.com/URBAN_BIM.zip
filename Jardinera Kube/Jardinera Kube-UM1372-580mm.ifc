Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-22T21:31:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 21:31:39 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\a90df35c-1758-4146-86b0-fd69ab5f04b1\efbf2335-f1c6-4a0e-aba1-a9eb2677511f\ifc * Database version: 5507 * Database creation date: Wed Mar 22 21:31:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 21:31:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 21:31:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Kube:Jardinera Kube-UM1372-580mm, Jardinera Kube:Jardinera Kube-UM1372-580mm:709959
In: Level 1
Type - Material: Concrete (2)
Type - PRODUCT_PROPERTIES - 02 Material: Hormigón prefabricado; 03 Dimension_A: 0.58 m; 03 Dimension_H: 0.58 m; 03 Dimension_B: 0.58 m; 04 Descripción: Jardinera fabricada en hormigón prefabricado color gris granítico de aspecto rugoso; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso; 06 Referencia: UM1372; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/kube--UM1372.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1372; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Kube: Jardinera Kube-UM1372-580mm
