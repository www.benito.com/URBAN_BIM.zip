Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-27T22:15:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 27 22:15:14 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\83910a8c-b1dc-4711-87a9-5560787aa8c9\5d1d9f58-3950-4667-86e1-413e99f87ea9\ifc * Database version: 5507 * Database creation date: Mon Feb 27 22:15:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 27 22:15:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 27 22:15:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Ensanche:Valla Ensanche-VVBA210-1195mm, Valla Ensanche:Valla Ensanche-VVBA210-1195mm:377431
In: Level 1
Type - Material: Acero (9)
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 1.79 m; 03 Dimension_H: 1.195 m; 03 Dimension_H1: 0.2 m; 03 Dimension_B: 0.05 m; 04 Descripción: Valla fabricada en acero con tratamiento Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón.; 06 Referencia: VVBA210; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/ensanche--VVBA210.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVBA210; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Ensanche: Valla Ensanche-VVBA210-1195mm
