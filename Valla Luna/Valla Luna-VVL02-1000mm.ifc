Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T12:46:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 12:46:09 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\a9c34a21-9a65-49ef-8549-807173b8eaa3\142b13eb-4529-4f48-a989-810383437616\ifc * Database version: 5507 * Database creation date: Tue Feb 21 12:46:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 12:46:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 12:46:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcRailing: Railing:Valla Luna-VVL02-1000mm, Railing:Valla Luna-VVL02-1000mm:205888
In: Level 1
PRODUCT_PROPERTIES - 01 Producto: Railing: Valla Luna-VVL02-1000mm; 02 Material: Acero; 03 Dimension_H: 1 m; 04 Descripción: Valla fabricada en acero con tratamiento Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión de M10, según superficie y proyecto.; 06 Referencia: VVL02; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/luna--VVL02.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVL02; 09 Fabricante: BENITO URBAN SL
