Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T22:27:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 22:27:52 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\d610461e-fb50-409f-92f1-3edaf2792bcc\ifc * Database version: 5507 * Database creation date: Fri Apr 21 22:27:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 22:27:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 22:27:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Alcorque Rel:Alcorque Rel-A86-1105mm, Alcorque Rel:Alcorque Rel-A86-1105mm:938423
In: Level 1
Type - Material: Galvanized Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero galvanizado; 03 Dimension_A: 1.105 m; 03 Dimension_H: 0.035 m; 03 Dimension_B: 1.105 m; 03 Dimension_D: 0.3 m; 04 Descripción: Alcorque fabricado en malla electrosoldada de 34 x 38 mm, entre ejes, pletina portante de 30 x 2mm, separador cuadrado de 4 mm entregirado.; 06 Referencia: A86; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/alcorques/rel--A83.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-A83
PRODUCT_PROPERTIES - 01 Producto: Alcorque Rel: Alcorque Rel-A86-1105mm
