Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T12:35:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 12:35:48 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\0aa59938-b115-4895-8ed2-cb7cb12ddfd7\ifc * Database version: 5507 * Database creation date: Sat Apr 22 12:35:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 12:35:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 12:35:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Rural:Valla Rural-VRV460-P1-1500mm, Valla Rural:Valla Rural-VRV460-P1-1500mm:962312
In: Level 1
Type - Material: Pine Wood
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0 m; 03 Dimension_H1: 0 m; 02 Material: Madera de pino; 03 Dimension_H: 1.5 m; 03 Dimension_D: 0.12 m; 04 Descripción: Valla fabricada en madera de pino con tratamiento autoclave a vacío-presión clase 4 contra la carcoma, termitas e insectos. Postes de Ø 120 x 1500 mm. Travesaños de Ø 80 x 2000mm; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón; 06 Referencia: VRV460; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/rural--VRV460.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRV460; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Rural: Valla Rural-VRV460-P1-1500mm
