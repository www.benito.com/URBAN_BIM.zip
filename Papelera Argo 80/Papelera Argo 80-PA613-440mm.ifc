Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T19:45:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 19:45:56 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\022ba53e-5375-49e4-8be7-6c84721cd6e0\ifc * Database version: 5507 * Database creation date: Tue Mar 07 19:45:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 19:45:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 19:45:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Argo 80:Papelera Argo 80-PA613-440mm, Papelera Argo 80:Papelera Argo 80-PA613-440mm:462438
In: Level 1
Type - Material: Gi Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero zincado; 03 Dimension_A: 0.44 m; 03 Dimension_H: 0.91 m; 03 Dimension_H1: 0.3 m; 03 Dimension_B: 0.61 m; 04 Descripción: Cubeta y estructura en acero zincado; 05 Información_Adicional: Anclaje recomendado: Fijación al suelo mediante 3 tornillos Ø8, no suministrados; 06 Referencia: PA613; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/argo-80--PA613.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA613; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Papelera Argo 80: Papelera Argo 80-PA613-440mm
