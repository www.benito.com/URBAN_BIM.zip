Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T17:27:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 17:27:47 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\e461f35a-6a99-4e97-8747-54e3875511b0\ifc * Database version: 5507 * Database creation date: Fri Mar 10 17:27:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 17:27:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 17:27:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Valles:Banco Valles-UM340-2065mm, Banco Valles:Banco Valles-UM340-2065mm:590206
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 2.065 m; 03 Dimension_H: 0.855 m; 03 Dimension_H1: 0.43 m; 03 Dimension_B: 0.76 m; 04 Descripción: Banco fabricado con pies de tubo de acero de Ø40 mm con asiento y respaldo de plancha de acero perforada de 2 mm de grueso y agujeros de Ø7 mm; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM340; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/valles--UM340.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM340; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Valles: Banco Valles-UM340-2065mm
