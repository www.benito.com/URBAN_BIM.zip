Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T17:29:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 17:29:54 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\2e0cddee-469b-4f80-b294-29e732f1192b\ifc * Database version: 5507 * Database creation date: Fri Mar 10 17:29:48 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 17:29:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 17:29:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Valles:Banco Valles-UM340B-2080mm, Banco Valles:Banco Valles-UM340B-2080mm:590206
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 03 Dimension_H: 0 m; 02 Material: Acero; 03 Dimension_A: 2.08 m; 03 Dimension_H1: 0.45 m; 03 Dimension_B: 0.5 m; 04 Descripción: Banqueta fabricada con pies de tubo de acero de Ø40 mm con asiento y respaldo de plancha de acero perforada de 2 mm de grosor y agujeros de Ø7 mm; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM340B; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/banqueta-valles--UM340B.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM340B; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Valles: Banco Valles-UM340B-2080mm
