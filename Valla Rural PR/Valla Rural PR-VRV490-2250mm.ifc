Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T14:16:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 14:16:53 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\8bca701a-fd03-401d-b62b-5da0b1621a68\ifc * Database version: 5507 * Database creation date: Sat Apr 22 14:16:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 14:16:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 14:16:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Rural PR:Valla Rural PR-VRV490-2250mm, Valla Rural PR:Valla Rural PR-VRV490-2250mm:999296
In: Level 1
Type - Material: Rebnew
Type - PRODUCT_PROPERTIES - 02 Material: Rebnew; 03 Dimension_A: 2.25 m; 03 Dimension_H: 1.5 m; 03 Dimension_D: 0.12 m; 04 Descripción: Valla fabricada en plástico reciclado ReBnew,Sin mantenimiento. Postes cuadrados 120 x 120 x 1500 mm. Travesaños de Ø 80 x 2225 mm.; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón.; 06 Referencia: VRV490; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/rural-pr--VRV490.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRV490; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Rural PR: Valla Rural PR-VRV490-2250mm
