Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T18:24:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 18:24:02 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\a9d5bf23-99ca-43e0-9846-57bf7a0dd024\ifc * Database version: 5507 * Database creation date: Fri Mar 10 18:23:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 18:23:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 18:23:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Circular:Papelera Circular Inox-PA600MI-465mm, Papelera Circular:Papelera Circular Inox-PA600MI-465mm:642178
In: Level 1
Type - Material: Inox
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.465 m; 03 Dimension_H: 0.885 m; 03 Dimension_H1: 0.525 m; 03 Dimension_B: 0.375 m; 04 Descripción: Papelera fabricada con cubeta abatible de acero inoxidable AISI 304 pulido brillante; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M8; 06 Referencia: PA600MI; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/circular-inox--PA600MI.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA600MI; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Papelera Circular: Papelera Circular Inox-PA600MI-465mm
