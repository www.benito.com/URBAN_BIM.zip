Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T13:48:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 13:48:24 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\a9c34a21-9a65-49ef-8549-807173b8eaa3\de6e764a-7c5f-4beb-be6e-d631e4c1adf5\ifc * Database version: 5507 * Database creation date: Tue Feb 21 13:48:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 13:48:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 13:48:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Bardal:Valla Bardal 200-VVP200A-2000mm, Valla Bardal:Valla Bardal 200-VVP200A-2000mm:345518
In: Level 1
Type - Material: Polipropileno (26)
Type - PRODUCT_PROPERTIES - 02 Material: Polipropileno; 03 Dimension_A: 2 m; 03 Dimension_H: 1.021 m; 03 Dimension_B: 0.555 m; 04 Descripción: Las Vallas de plástico Bardal són resitentes, estables y de fácil transporte.; 05 Información_Adicional: Diseño estable ideal para señalizar y mantener distancias en; 06 Referencia: VVP200A; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/bardal-200--VVP200A.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVP200A
PRODUCT_PROPERTIES - 01 Producto: Valla Bardal: Valla Bardal 200-VVP200A-2000mm
