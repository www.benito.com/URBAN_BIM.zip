Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T20:19:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.1.0.1 - Alternate UI 20.1.0.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 20:19:18 2023 * Host: Cristina_CIBIM * Database: C:\Users\CIBIM\AppData\Local\Temp\24aa930e-4ed6-4ff3-bbc9-eb55fbe84bac\1b702950-6275-4188-8d9a-ee763ce4cf38\ifc * Database version: 5507 * Database creation date: Fri Apr 21 20:19:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 20:19:17 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 20:19:17 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Grey:Pilona Grey-H221-1000mm, Pilona Grey:Pilona Grey-H221-1000mm:911917
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.1 m; 03 Dimension_B: 1 m; 04 Descripción: Pilona en forma de vigueta de acero Grey-100 con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión.; 06 Referencia: H221; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/grey--H221.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H221; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Grey: Pilona Grey-H221-1000mm
