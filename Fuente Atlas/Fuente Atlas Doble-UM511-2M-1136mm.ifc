Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-23T10:02:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Apr 23 10:02:54 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\d13a4621-f060-406d-826a-62ef2b55888b\26ef43d3-eab4-4317-8af2-b8d2b4521a36\ifc * Database version: 5507 * Database creation date: Sun Apr 23 10:02:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Apr 23 10:02:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Apr 23 10:02:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Atlas:Fuente Atlas Doble-UM511-2M-1136mm, Fuente Atlas:Fuente Atlas Doble-UM511-2M-1136mm:1017954
In: Level 1
Type - Material: Cast Iron
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 1.136 m; 03 Dimension_H: 1.01 m; 03 Dimension_H1: 0.9 m; 03 Dimension_B: 0.3 m; 04 Descripción: La Fuente Atlas tiene una estructura sobria con un cuerpo cuadrado de hierro, grifo niquelado, una reja sumidero de fundición dúctil y marco de hierro que evita que se esparza el agua por los alrededores.; 06 Referencia: UM511-2M; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/atlas-doble--UM511-2M.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM511-2M; 09 Fabricante: BENITO URBAN SL
Material: Cast Iron, Stainless Steel
PRODUCT_PROPERTIES - 01 Producto: Fuente Atlas: Fuente Atlas Doble-UM511-2M-1136mm
