Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T20:06:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 20:06:08 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\d30f8ca3-b7fd-4b2b-b387-37b88b4498d2\ifc * Database version: 5507 * Database creation date: Fri Apr 21 20:06:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 20:06:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 20:06:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Rustica:Valla Rustica-VRV440-1500mm, Valla Rustica:Valla Rustica-VRV440-1500mm:901099
In: Level 1
Type - Material: Pine Wood
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 2 m; 03 Dimension_H: 1.5 m; 03 Dimension_H1: 0.8 m; 03 Dimension_D: 0.12 m; 04 Descripción: Valla fabricada en madera de pino con tratamiento autoclave a vacío-presión clase 4 contra la carcoma, termitas e insectos. Postes de Ø 120 x 1500 mm. Travesaños de Ø 80 x 2000 mm. Barrotes de media caña de Ø 90 mm; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón.; 06 Referencia: VRV440; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/rustica--VRV440.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRV440; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Rustica: Valla Rustica-VRV440-1500mm
