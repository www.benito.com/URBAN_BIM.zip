Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-08T21:13:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 08 21:13:20 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\34012f6d-a60f-4dbd-b13d-28ca7485536f\770a2770-f189-4fdb-89ab-a27e7841313c\ifc * Database version: 5507 * Database creation date: Wed Mar 08 21:13:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 08 21:13:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 08 21:13:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Kube Selectif:Papelera Kube Selectif-PA672S3-510mm, Papelera Kube Selectif:Papelera Kube Selectif-PA672S3-510mm:548215
In: Level 1
Type - Material: Steel PA672SAZ, Steel Blue
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0 m; 03 Dimension_H: 0 m; 03 Dimension_B: 0 m; 02 Material: Hormigón prefabricado; 04 Descripción: Papelera fabricada en hormigón prefabricado color gris granítico de aspecto rugoso; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso; 06 Referencia: PA672S3; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/papelera-kube-selectif--PA672S3.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA672S3; 09 Fabricante: BENITO URBAN SL
Material: Steel Blue, Steel Yellow, Steel Brown, Steel Black, Concrete
PRODUCT_PROPERTIES - 01 Producto: Papelera Kube Selectif: Papelera Kube Selectif-PA672S3-510mm
