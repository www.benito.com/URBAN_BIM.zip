Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T22:52:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 22:52:45 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2306e0ad-f087-4bcf-9211-598b6fcefd24\ac4d159f-072e-4f6d-8dc8-8939a9951d64\ifc * Database version: 5507 * Database creation date: Tue Feb 21 22:52:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 22:52:45 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 22:52:45 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Semiautomatica_140:Pilona Semiautomatica-H275TR-140mm, Pilona Telescopica Semiautomatica_140:Pilona Semiautomatica-H275TR-140mm:368675
In: Level 1
Type - Material: <Unnamed>, Reflectante Blanca, Acero inoxidable, Acero galvanizado
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.14 m; 03 Dimension_H: 1.245 m; 03 Dimension_H1: 0.745 m; 03 Dimension_C: 0.3 m; 03 Dimension_D: 0.5 m; 03 Dimension_Espesor: 0.008 m; 04 Descripción: La Pilona Telescópica destaca por ser simple, práctica y de fácil manejo; 06 Referencia: H275TR; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-semiautomatica-%C3%98140-x-500--H275TR.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H275TR; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Semiautomatica_140: Pilona Semiautomatica-H275TR-140mm
