Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T09:43:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 09:43:13 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\4dbb7949-b145-445b-8eb1-2327923eda98\ifc * Database version: 5507 * Database creation date: Wed Apr 05 09:43:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 09:43:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 09:43:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Milos:Pilona Milos-H415-175mm, Pilona Milos:Pilona Milos-H415-175mm:805655
In: Level 1
Type - Material: Milos
Type - PRODUCT_PROPERTIES - 02 Material: Polietilieno; 03 Dimension_A: 0.175 m; 03 Dimension_H: 0.585 m; 03 Dimension_H1: 0.135 m; 04 Descripción: Pilona fabricada en polietileno de baja y alta densidad, compactado. Interior con goma reciclada de caucho; 05 Información_Adicional: Con dos bandas reflectantes en la parte superior e inferior; 06 Referencia: H415; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-semiflexibles/milos--H415.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H415; 09 Fabricante: BENITO URBAN SL
Material: Milos, Milos1
PRODUCT_PROPERTIES - 01 Producto: Pilona Milos: Pilona Milos-H415-175mm
