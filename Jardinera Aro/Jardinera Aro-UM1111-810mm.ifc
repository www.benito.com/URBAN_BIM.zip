Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-16T09:09:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 16 09:09:42 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\56256061-0387-4b93-adbf-ac73e904bdcc\d2a88898-af54-4def-a92d-c77130875a8a\ifc * Database version: 5507 * Database creation date: Thu Mar 16 09:09:38 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 16 09:09:41 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 16 09:09:41 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Aro:Jardinera Aro-UM1111-810mm, Jardinera Aro:Jardinera Aro-UM1111-810mm:698411
In: Level 1
Type - Material: Acero Ferrus
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.81 m; 03 Dimension_H: 0.56 m; 04 Descripción: La Jardinera Aro destaca por su aspecto robusto pero a la vez por su diseño simple pero estético; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso.; 06 Referencia: UM1111; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/aro--UM1111.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1111; 09 Fabricante: BENITO URBAN SL
Material: Acero Ferrus, Aluminium
PRODUCT_PROPERTIES - 01 Producto: Jardinera Aro: Jardinera Aro-UM1111-810mm
