Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T11:57:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 11:57:34 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\bea02b98-b2b5-4bf1-bf8f-c63b1f4db364\ifc * Database version: 5507 * Database creation date: Sat Apr 22 11:57:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 11:57:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 11:57:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Sol:Valla Sol-VVP002-2000mm, Valla Sol:Valla Sol-VVP002-2000mm:956379
In: Level 1
Type - Material: Iron
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 2 m; 03 Dimension_H: 1.11 m; 03 Dimension_H1: 0.83 m; 04 Descripción: Valla fabricada íntegramente en hierro con estructura reforzada, tratada con Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón; 06 Referencia: VVP002; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/sol--VVP002.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVP002; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Sol: Valla Sol-VVP002-2000mm
