Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-16T09:15:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 16 09:15:42 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\56256061-0387-4b93-adbf-ac73e904bdcc\de846bdd-12ad-468d-8213-b5132e56a8c4\ifc * Database version: 5507 * Database creation date: Thu Mar 16 09:15:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 16 09:15:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 16 09:15:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Das:Jardinera Das-UM1159-745mm, Jardinera Das:Jardinera Das-UM1159-745mm:699338
In: Level 1
Type - Material: Acero zincado
Type - PRODUCT_PROPERTIES - 02 Material: Acero zincado; 03 Dimension_A: 0.745 m; 03 Dimension_H: 0.5 m; 03 Dimension_B: 0.745 m; 04 Descripción: Fabricada en acero zincado. Zincado con imprimación epoxi y pintura poliester en polvo color acero corten.; 05 Información_Adicional: Fijación al suelo mediante tornillos M10, no subministrados.; 06 Referencia: UM1159; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/das--UM1159.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1159; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Das: Jardinera Das-UM1159-745mm
