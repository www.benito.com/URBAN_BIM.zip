Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T20:08:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 20:08:14 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\94bf6cbe-8e69-48a4-9378-91eb07cf6eef\ifc * Database version: 5507 * Database creation date: Fri Mar 10 20:08:11 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 20:08:13 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 20:08:13 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Doria:Papelera Doria-PA686-620mm, Papelera Doria:Papelera Doria-PA686-620mm:690665
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 0.62 m; 03 Dimension_H: 0.91 m; 03 Dimension_H1: 0.82 m; 04 Descripción: Papelera de gran capacidad con cenicero central, diseñada para ofrecer una solución a la separación de residuos; 05 Información_Adicional: Fijación recomendada sobre suelo duro o dado de hormigón, mediante tres pernos Ø10; 06 Referencia: PA686; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/doria--PA686.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA686; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Papelera Doria: Papelera Doria-PA686-620mm
