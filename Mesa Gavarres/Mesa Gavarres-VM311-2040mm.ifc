Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T14:45:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 14:45:01 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\e389133c-d126-4eee-8b0b-afe85ac51f5c\ifc * Database version: 5507 * Database creation date: Sat Apr 22 14:44:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 14:45:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 14:45:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Mesa Gavarres:Mesa Gavarres-VM311-2040mm, Mesa Gavarres:Mesa Gavarres-VM311-2040mm:1004413
In: Level 1
Type - Material: Madera de pino (40)
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 2.04 m; 03 Dimension_H: 0.81 m; 03 Dimension_H1: 0.44 m; 03 Dimension_B: 0.67 m; 03 Dimension_C: 0.4 m; 04 Descripción: Mesa fabricada en madera de pino tratada en autoclave a vacío-presión clase 4 contra la carcoma, termitas e insectos. Tornillería de acero inoxidable. Pies en plancha de acero corten de 8 mm; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10, según superficie y instalación.; 06 Referencia: VM311; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/mesas/gavarres--VM311.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VM311; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Mesa Gavarres: Mesa Gavarres-VM311-2040mm
