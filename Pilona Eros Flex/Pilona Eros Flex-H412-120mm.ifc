Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T13:59:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 13:59:57 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\df821c7c-8a94-4e0c-9f25-5e788318adb5\ifc * Database version: 5507 * Database creation date: Wed Apr 05 13:59:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 13:59:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 13:59:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Eros Flex:Pilona Eros Flex-H412-120mm, Pilona Eros Flex:Pilona Eros Flex-H412-120mm:871370
In: Level 1
Type - Material: <Unnamed>, Aluminium, Polyethylene
Type - PRODUCT_PROPERTIES - 02 Material: Polietilieno; 03 Dimension_A: 0.12 m; 03 Dimension_H: 0.9 m; 03 Dimension_H1: 0.2 m; 03 Dimension_B: 0.073 m; 04 Descripción: Pilona fabricada en polietileno de baja y alta densidad, compactado. Su interior con goma reciclada de caucho lo que le permite soportar grandes impactos.; 05 Información_Adicional: Con dos bandas reflectantes en la parte superior e inferior.; 06 Referencia: H412; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-semiflexibles/eros-flex--H412.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H412; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Eros Flex: Pilona Eros Flex-H412-120mm
