Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T14:50:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 14:50:10 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\c41c6340-5712-4093-9ff6-8693c219a2a1\ifc * Database version: 5507 * Database creation date: Wed Apr 05 14:50:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 14:50:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 14:50:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Fija:Pilona Fija de Protectcion Amarilla Y Negra-H226P-800mm, Pilona Fija:Pilona Fija de Protectcion Amarilla Y Negra-H226P-800mm:876889
In: Level 1
Type - Material: Steel (Y)
Type - PRODUCT_PROPERTIES - 02 Material: Acero con pintura; 03 Dimension_A: 0.114 m; 03 Dimension_H: 0.8 m; 04 Descripción: Pilona fija de protección amarilla y negra de acero y pintura epoxi; 05 Información_Adicional: Acabado color amarillo y negro; 06 Referencia: H226P; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/fija-de-proteccion-amarilla-y-negra--H226P.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H226P; 09 Fabricante: BENITO URBAN SL
Material: Steel (Y), Steel (B)
PRODUCT_PROPERTIES - 01 Producto: Pilona Fija: Pilona Fija de Protectcion Amarilla Y Negra-H226P-800mm
