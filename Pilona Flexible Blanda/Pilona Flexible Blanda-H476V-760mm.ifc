Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T13:50:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 13:50:48 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\06569ced-ab5f-4fbc-b51c-a664987b191d\a95c765d-944a-4dfb-99d4-c4ad4b522941\ifc * Database version: 5507 * Database creation date: Fri Apr 21 13:50:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 13:50:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 13:50:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Flexible Blanda:Pilona Flexible Blanda-H476V-760mm, Pilona Flexible Blanda:Pilona Flexible Blanda-H476V-760mm:876889
In: Level 1
Type - Material: PVC White
Type - PRODUCT_PROPERTIES - 02 Material: Poliuretano flexible; 03 Dimension_A: 0.08 m; 03 Dimension_H: 0.76 m; 03 Dimension_B: 0.2 m; 04 Descripción: Pilona blanda fabricada en poliuretano flexible color verde, con tres bandas reflectantes.; 05 Información_Adicional: Anclaje recomendado: Atornillada al suelo.; 06 Referencia: H476V; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-flexibles/flexible-blanda--H476V.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H476V; 09 Fabricante: BENITO URBAN SL
Material: PVC White, PVC Green
PRODUCT_PROPERTIES - 01 Producto: Pilona Flexible Blanda: Pilona Flexible Blanda-H476V-760mm
