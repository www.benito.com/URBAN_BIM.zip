Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T11:35:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 11:35:53 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\c0f4f9bc-5d53-448f-a9d5-fb4824ee76e2\ifc * Database version: 5507 * Database creation date: Wed Apr 05 11:35:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 11:35:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 11:35:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona BAR atornillable:Pilona BAR atornillable-H414VA-80mm, Pilona BAR atornillable:Pilona BAR atornillable-H414VA-80mm:859593
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 02 Material: Polyurethane; 03 Dimension_A: 0.08 m; 03 Dimension_H: 0.87 m; 03 Dimension_B: 0.16 m; 04 Descripción: Pilona fabricada en poliuretano, con placa de refuerzo en acero inoxidable; 05 Información_Adicional: Absorbe cualquier impacto de vehículos y recupera la verticalidad al 100%. Supera una flexión de 1500 ciclos a 45º y 50 ciclos a 90º, sin daños. Clasificación “E” de comportamiento al fuego, según norma UNE-EN 13501-1:2007+A1:2010. Resistente a -50º según norma UNE ISO 812.; 06 Referencia: H414VA; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-flexibles/bar-atornillable--H214VA.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H214VA; 09 Fabricante: BENITO URBAN SL
Material: Stainless Steel, Polyurethane
PRODUCT_PROPERTIES - 01 Producto: Pilona BAR atornillable: Pilona BAR atornillable-H414VA-80mm
