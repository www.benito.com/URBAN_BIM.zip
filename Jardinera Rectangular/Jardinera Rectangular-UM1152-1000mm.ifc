Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-28T13:22:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 28 13:22:56 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\3c79c539-4885-4fcd-bc65-b27275f692d0\1844c5f5-b075-4077-9f99-317f14cf9d35\ifc * Database version: 5507 * Database creation date: Tue Mar 28 13:22:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 28 13:22:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 28 13:22:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Rectangular:Jardinera Rectangular-UM1152-1000mm, Jardinera Rectangular:Jardinera Rectangular-UM1152-1000mm:773308
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 1 m; 03 Dimension_H: 0.52 m; 03 Dimension_H1: 0.44 m; 03 Dimension_B: 0.425 m; 04 Descripción: Jardinera fabricada en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM1152; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/rectangular--UM1152.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1152; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Rectangular: Jardinera Rectangular-UM1152-1000mm
