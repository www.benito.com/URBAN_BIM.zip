Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T22:03:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 22:03:33 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2306e0ad-f087-4bcf-9211-598b6fcefd24\881c1eec-a6b8-420c-baa6-bc613c8cba2c\ifc * Database version: 5507 * Database creation date: Tue Feb 21 22:03:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 22:03:33 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 22:03:33 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Semiautomatica:Pilona Semiautomatica-H2208-220mm, Pilona Telescopica Semiautomatica:Pilona Semiautomatica-H2208-220mm:366530
In: Level 1
Type - Material: Reflectante Blanca
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.22 m; 03 Dimension_B: 0.67 m; 03 Dimension_C: 0.5 m; 03 Dimension_D: 0.274 m; 03 Dimension_Espesor: 0.008 m; 04 Descripción: Pilona diseñada para control de acceso en la vía pública, en comunidades, empresas, etc; 05 Información_Adicional: Bloqueo automático tanto en posición subida como bajada, desbloqueo mediante llave triangular DIN3223.; 06 Referencia: H2208; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-semiautomatica-con-llave-%C3%98220-x-500m--H2208.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H2208; 09 Fabricante: BENITO URBAN SL
Material: Reflectante Blanca, Acero inoxidable, Acero galvanizado
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Semiautomatica: Pilona Semiautomatica-H2208-220mm
