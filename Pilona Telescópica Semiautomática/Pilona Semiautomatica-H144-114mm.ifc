Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-23T10:34:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 23 10:34:34 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\1ec83315-8369-4a8d-be6c-3787cd9505e9\b2ed1a5e-7b5b-4853-aef1-bdea3d52168b\ifc * Database version: 5507 * Database creation date: Thu Feb 23 10:34:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 23 10:34:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 23 10:34:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Semiautomatica:Pilona Semiautomatica-H1144-114mm, Pilona Telescopica Semiautomatica:Pilona Semiautomatica-H1144-114mm:369687
In: Level 1
Type - Material: Reflectante Blanca
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.114 m; 03 Dimension_B: 0.67 m; 03 Dimension_C: 0.5 m; 03 Dimension_D: 0.2 m; 03 Dimension_Espesor: 0.004 m; 04 Descripción: Pilona diseñada para control de acceso en la vía pública, en comunidades, empresas, etc; 05 Información_Adicional: Bloqueo automático tanto en posición subida como bajada, desbloqueo mediante llave triangular DIN3223.; 06 Referencia: H1144; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-semiautomatica-con-llave-%C3%98114-x-500m--H1144.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H1144; 09 Fabricante: BENITO URBAN SL
Material: Reflectante Blanca, Acero inoxidable, Acero galvanizado
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Semiautomatica: Pilona Semiautomatica-H1144-114mm
