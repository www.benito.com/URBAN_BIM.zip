Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T19:19:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 19:19:32 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\f05d4de9-4b05-4982-8bdc-9dbe9fa544c3\ifc * Database version: 5507 * Database creation date: Tue Mar 07 19:19:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 19:19:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 19:19:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Bretana:Banco Bretana-UM374B-1800mm, Banco Bretana:Banco Bretana-UM374B-1800mm:456799
In: Level 1
Type - Material: Iron
Type - PRODUCT_PROPERTIES - 03 Dimension_H: 0 m; 03 Dimension_A: 1.8 m; 03 Dimension_H1: 0.445 m; 03 Dimension_B: 0.5 m; 04 Descripción: Banqueta fabricada con pies de fundición dúctil; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto; 06 Referencia: UM374B; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/bretana-b--UM374B.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM374B; 09 Fabricante: BENITO URBAN SL
Material: Iron, Wood
PRODUCT_PROPERTIES - 01 Producto: Banco Bretana: Banco Bretana-UM374B-1800mm
