Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T19:18:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 19:18:16 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\c2522704-638a-48a4-9564-602f1d8c5774\ifc * Database version: 5507 * Database creation date: Tue Mar 07 19:18:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 19:18:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 19:18:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Bretana:Banco Bretana-UM374-1800mm, Banco Bretana:Banco Bretana-UM374-1800mm:456799
In: Level 1
Type - Material: Iron
Type - PRODUCT_PROPERTIES - 02 Material Pies: Fundición dúctil; 02 Material Tablones: Madera trópical; 03 Dimension_A: 1.8 m; 03 Dimension_H: 0.77 m; 03 Dimension_H1: 0.445 m; 03 Dimension_B: 0.63 m; 04 Descripción: Banqueta fabricada con pies de fundición dúctil; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto; 06 Referencia: UM374; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/bretana--UM374.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM374; 09 Fabricante: BENITO URBAN SL
Material: Iron, Wood
PRODUCT_PROPERTIES - 01 Producto: Banco Bretana: Banco Bretana-UM374-1800mm
