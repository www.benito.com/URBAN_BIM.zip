Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T20:59:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 20:59:54 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2306e0ad-f087-4bcf-9211-598b6fcefd24\b7b63728-a6e2-4753-a9c3-bc1d14f44dd3\ifc * Database version: 5507 * Database creation date: Tue Feb 21 20:59:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 20:59:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 20:59:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Automatica_275:Pilona Automatica-H275AHG-275mm, Pilona Telescopica Automatica_275:Pilona Automatica-H275AHG-275mm:365585
In: Level 1
Type - Material: Acero inoxidable
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.273 m; 03 Dimension_H: 1.482 m; 03 Dimension_H1: 0.882 m; 03 Dimension_B: 0.4 m; 03 Dimension_C: 0.45 m; 03 Dimension_D: 0.6 m; 03 Dimension_Espesor: 0.004 m; 04 Descripción: Pilona automática fabricada con émbolo de acero inoxidable AISI-304 brillante de Ø270 x 600 mm de altura; 05 Información_Adicional: Señalización formada por 4 leds rojos y una banda reflectante blanca en la parte superior. Incluye 2 bucles de seguridad y mando a distancia.; 06 Referencia: H275AHG; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-automatica-%C3%98275--H275AHG.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H275AHG; 09 Fabricante: BENITO URBAN SL
Material: Acero inoxidable, Reflectante Blanca, LED Rojo, Acero galvanizado
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Automatica_275: Pilona Automatica-H275AHG-275mm
