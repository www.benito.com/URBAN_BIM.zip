Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:28:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:28:54 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\d8f83e08-ce2c-46d5-a46f-7626ae3b6b4a\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:28:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:28:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:28:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Mesa Picnik:Mesa Picnik-VRM200-1750mm, Mesa Picnik:Mesa Picnik-VRM200-1750mm:979801
In: Level 1
Type - Material: Madera de pino
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 1.75 m; 03 Dimension_H: 0.76 m; 03 Dimension_H1: 0.44 m; 03 Dimension_B: 1.68 m; 04 Descripción: Mesa fabricada en madera de pino tratada en autoclave a vacío-presión clase 4 contra la carcoma, termitas, insectos. Tablones de 1750 x 95 x 40mm.; 06 Referencia: VRM200; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/mesas/picnik--VRM200SM.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRM200SM; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Mesa Picnik: Mesa Picnik-VRM200-1750mm
