Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T13:47:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 13:47:49 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\7166d65d-2c04-41a1-8b28-784ec8abd0b6\1ee168f3-b0e4-4218-b52e-bffc8663f085\ifc * Database version: 5507 * Database creation date: Tue Mar 07 13:47:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 13:47:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 13:47:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Volga:Banco Volga-UM369-2000mm, Banco Volga:Banco Volga-UM369-2000mm:449883
In: Level 1
Type - Material: Precast Concrete
Type - PRODUCT_PROPERTIES - 02 Material Banco: Hormigón prefabricado; 03 Dimension_A: 2 m; 03 Dimension_H: 0.45 m; 03 Dimension_B: 0.6 m; 04 Descripción: Banco fabricado en hormigón prefabricado color blanco granítico de aspecto liso; 05 Información_Adicional: Anclaje recomendado: apoyado en el suelo en sus extremos robustos con el objetivo de facilitar la limpieza y el mantenimiento.; 06 Referencia: UM369; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/volga--UM369.html?gclid=CjwKCAiA3pugBhAwEiwAWFzwdRFvoC8qWjxvLGyfSXHZHkYjS_qWY0jgdf05UNwZQawIB1VIhcQR2RoCFzwQAvD_BwE; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM369; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Volga: Banco Volga-UM369-2000mm
