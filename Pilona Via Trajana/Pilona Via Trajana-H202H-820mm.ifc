Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:06:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.1.0.1 - Alternate UI 20.1.0.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:06:00 2023 * Host: Cristina_CIBIM * Database: C:\Users\CIBIM\AppData\Local\Temp\fd246e26-048e-40bc-9db4-38f1fa625283\60f3f607-fdd7-48ac-9706-4db3ba2d1460\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:05:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:05:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:05:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Via Trajana MH:Pilona Via Trajana-H202H-820mm, Pilona Via Trajana MH:Pilona Via Trajana-H202H-820mm:921977
In: Level 1
Type - Material: H202H(1)
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.12 m; 03 Dimension_H: 0.82 m; 03 Dimension_H1: 0.125 m; 03 Dimension_B: 0.102 m; 04 Descripción: Pilona fabricada en acero con tratamiento Ferrus; 06 Referencia: H202H; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/via-trajana--H202H.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H202H; 09 Fabricante: BENITO URBAN, SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Via Trajana MH: Pilona Via Trajana-H202H-820mm
