Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:15:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.1.0.1 - Alternate UI 20.1.0.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:15:31 2023 * Host: Cristina_CIBIM * Database: C:\Users\CIBIM\AppData\Local\Temp\fd246e26-048e-40bc-9db4-38f1fa625283\694d64de-65ee-48f4-ba9b-5c4d298a1b8b\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:15:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:15:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:15:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Via Trajana Movil:Pilona Via Trajana Movil H202MH-1C-825mm, Pilona Via Trajana Movil:Pilona Via Trajana Movil H202MH-1C-825mm:921977
In: Level 1
Type - Material: H202H(1)
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0.12 m; 03 Dimension_H: 0.825 m; 03 Dimension_H1: 0.13 m; 03 Dimension_B: 0.114 m; 04 Descripción: Acero zincado con imprimación epoxi y pintura poliéster en polvo color negro RAL9005; 05 Información_Adicional: Instalación: Con base extraíble; 06 Referencia: H202MH-1C; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/via-trajana-movil--H202MH-1C.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H202MH-1C; 09 Fabricante: BENITO URBAN SL
Material: H202H(1), H202H
PRODUCT_PROPERTIES - 01 Producto: Pilona Via Trajana Movil: Pilona Via Trajana Movil H202MH-1C-825mm
