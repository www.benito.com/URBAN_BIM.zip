Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T12:59:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 12:59:55 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\d10e9119-86a9-4f0a-ae31-d2c87a476158\ifc * Database version: 5507 * Database creation date: Sat Apr 22 12:59:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 12:59:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 12:59:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Metálica:Valla Metálica-VVP034-2100mm, Valla Metálica:Valla Metálica-VVP034-2100mm:965909
In: Level 1
Type - Material: Steel(4)
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 2.1 m; 03 Dimension_H: 1.2 m; 03 Dimension_H1: 0.68 m; 03 Dimension_D: 0.1 m; 04 Descripción: Valla fabricada en tubo de acero con tratamiento Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Base empotrable +/- 300mm.; 06 Referencia: VVP034; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/metalica--VVP034.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVP034; 09 Fabricante: BENITO URBAN SL
Material: Steel(4), Steel(2), Steel(1), Steel(3)
PRODUCT_PROPERTIES - 01 Producto: Valla Metálica: Valla Metálica-VVP034-2100mm
