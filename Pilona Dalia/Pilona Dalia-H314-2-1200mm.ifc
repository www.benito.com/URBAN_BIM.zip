Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T11:49:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 11:49:06 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\5ab6e00c-23d4-4538-abbf-f77aa0929037\ifc * Database version: 5507 * Database creation date: Wed Apr 05 11:49:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 11:49:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 11:49:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Dalia:Pilona Dalia-H314-2-1200mm, Pilona Dalia:Pilona Dalia-H314-2-1200mm:863879
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.09 m; 03 Dimension_H: 1.2 m; 04 Descripción: Pilona fabricada en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión; 05 Información_Adicional: Parte superior con embellecedor de acero inoxidable.; 06 Referencia: H314-2; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/dalia--H314.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H314; 09 Fabricante: BENITO URBAN SL
Material: Stainless Steel, Polyurethane
PRODUCT_PROPERTIES - 01 Producto: Pilona Dalia: Pilona Dalia-H314-2-1200mm
