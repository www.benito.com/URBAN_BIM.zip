Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-23T09:40:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 23 09:40:34 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\7dc661f4-014b-4f65-b1a2-9d4be6537c24\c08e2ee5-f813-4a37-aa1c-a5a0ab2ce989\ifc * Database version: 5507 * Database creation date: Thu Mar 23 09:40:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 23 09:40:33 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 23 09:40:33 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Madera:Jardinera Madera-UM1640-2-1000mm, Jardinera Madera:Jardinera Madera-UM1640-2-1000mm:721680
In: Level 1
Type - Material: Wood
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 1 m; 03 Dimension_H: 0.45 m; 03 Dimension_B: 0.5 m; 04 Descripción: Tablones de madera de pino con tratamiento autoclave a vacio-presión clase 4 contra la carcoma, termitas e insectos; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso; 06 Referencia: UM1640-2; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/madera--UM1640-2.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1640-2; 09 Fabricante: BENITO URBAN SL
Material: Wood, Steel
PRODUCT_PROPERTIES - 01 Producto: Jardinera Madera: Jardinera Madera-UM1640-2-1000mm
