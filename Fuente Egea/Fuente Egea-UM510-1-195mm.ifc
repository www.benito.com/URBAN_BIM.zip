Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-23T09:38:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Apr 23 09:38:53 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\d13a4621-f060-406d-826a-62ef2b55888b\5240fe24-4fc3-4a07-85d2-741d690b02cf\ifc * Database version: 5507 * Database creation date: Sun Apr 23 09:38:50 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Apr 23 09:38:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Apr 23 09:38:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Egea:Fuente Egea-UM510-1-195mm, Fuente Egea:Fuente Egea-UM510-1-195mm:1008738
In: Level 1
Type - Material: Cast Iron
Type - PRODUCT_PROPERTIES - 02 Material: Acero con pintura; 03 Dimension_A: 0.195 m; 03 Dimension_H: 1 m; 03 Dimension_H1: 0.85 m; 04 Descripción: La Fuente Egea destaca del resto de las fuentes de la gama de Mobiliario Urbano por su acabado en color verde. Fabricada en hierro tiene una estructura principal redonda y grifo niquelado de presión.; 06 Referencia: UM510-1; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/egea--UM510-1.html?gclid=CjwKCAjwrpOiBhBVEiwA_473dOSE3dyiyDjUTyvmicyF0msx0HPOPJ1nYz0vc31xYRnwyR6WG6CmQhoChYAQAvD_BwE; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM510-1; 09 Fabricante: BENITO URBAN SL
Material: Cast Iron, Stainless Steel, Acero con pintura, Steel
PRODUCT_PROPERTIES - 01 Producto: Fuente Egea: Fuente Egea-UM510-1-195mm
