Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-17T17:12:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 17 17:12:09 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\59ecc31a-a08b-4f84-ba49-bfe6638f4015\e34bea9c-8e8a-487d-9cbd-7664017d1e28\ifc * Database version: 5507 * Database creation date: Fri Feb 17 17:12:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 17 17:12:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 17 17:12:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Access:Fuente Access-UM542-1000mm, Fuente Access:Fuente Access-UM542-1000mm:215041
In: Level 1
Type - Material: Acero
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 0.51 m; 03 Dimension_H: 1 m; 03 Dimension_H1: 1.004 m; 04 Descripción: Fuente fabricada con columna triangular de acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión M12, según superficie y proyecto.; 06 Referencia: UM542; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/access--UM542.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM542; 09 Fabricante: BENITO URBAN SL
Material: <Unnamed>
PRODUCT_PROPERTIES - 01 Producto: Fuente Access: Fuente Access-UM542-1000mm
