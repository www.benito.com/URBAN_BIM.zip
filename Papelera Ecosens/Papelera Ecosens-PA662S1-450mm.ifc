Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T19:59:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 19:59:08 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\9cf0c8d9-c57f-45d0-8708-d23edcd5b80f\ifc * Database version: 5507 * Database creation date: Tue Mar 07 19:59:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 19:59:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 19:59:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Ecosens:Papelera Ecosens-PA662S1-450mm, Papelera Ecosens:Papelera Ecosens-PA662S1-450mm:466441
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 02 Material Pies: Acero; 02 Material Tablones: Polimeros reciclados; 03 Dimension_A: 0.45 m; 03 Dimension_H: 0.96 m; 03 Dimension_B: 0.35 m; 04 Descripción: Papelera fabricada con pies de acero de 50 x 8 mm con tratamiento Ferrus; 05 Información_Adicional: Anclaje recomendado: Mediante cuatro pernos de expansión según superficie y proyecto; 06 Referencia: PA662S1; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/ecosens--PA662S1.html?gclid=CjwKCAiA3pugBhAwEiwAWFzwdfQwZxCdv_FDOiWhfy7NhTl3k1bX9krqZz2wOjq1RbdtBv-CibM49BoCtsEQAvD_BwE; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA662S1; 09 Fabricante: BENITO URBAN SL
Material: Steel, Wood
PRODUCT_PROPERTIES - 01 Producto: Papelera Ecosens: Papelera Ecosens-PA662S1-450mm
