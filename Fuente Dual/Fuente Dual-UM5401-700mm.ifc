Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-23T09:55:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Apr 23 09:55:38 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\d13a4621-f060-406d-826a-62ef2b55888b\1dcb67f1-5a76-480d-8f0a-a1f8d551eff4\ifc * Database version: 5507 * Database creation date: Sun Apr 23 09:55:35 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Apr 23 09:55:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Apr 23 09:55:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Dual:Fuente Dual-UM5401-700mm, Fuente Dual:Fuente Dual-UM5401-700mm:1011564
In: Level 1
Type - Material: Acero
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 0.7 m; 03 Dimension_H: 1.04 m; 03 Dimension_H1: 0.855 m; 03 Dimension_B: 0.55 m; 04 Descripción: Fuente fabricada con columna triangular y salpicaderos en inoxidable brillante y satinado. Embellecedores acabados pintura poliéster en polvo color rojo cobre.; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión M12, según superficie y proyecto; 06 Referencia: UM5401; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/dual--UM540I.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM540I; 09 Fabricante: BENITO URBAN SL
Material: Acero, Acero con pintura poliester
PRODUCT_PROPERTIES - 01 Producto: Fuente Dual: Fuente Dual-UM5401-700mm
