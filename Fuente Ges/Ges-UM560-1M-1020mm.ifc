Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-04T13:38:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 04 13:38:02 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\92fe019a-708f-49fa-abd0-12aaedc405eb\958ec255-06b2-4731-9b6a-04f0cd68c546\ifc * Database version: 5507 * Database creation date: Tue Apr 04 13:38:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 04 13:38:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 04 13:38:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Ges:Ges-UM560-1M-1020mm, Fuente Ges:Ges-UM560-1M-1020mm:784128
In: Level 1
Type - Material: Stainless Steel
Type - PRODUCT_PROPERTIES - 02 Material: COMVEG; 03 Dimension_A: 0.8 m; 03 Dimension_H: 1.02 m; 03 Dimension_H1: 0.87 m; 03 Dimension_B: 0.3 m; 04 Descripción: Fuente de COMVEG (composite vegetal) ecológico pintado en su masa. Reduce el impacto medioambiental, resistente a la intemperie e hidrófugo.; 05 Información_Adicional: Anclaje recomendado: Fijación al suelo mediante 4 tornillos Ø10, no suministrados.; 06 Referencia: UM560-1M; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/ges--UM560-1M.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM560-1M; 09 Fabricante: BENITO URBAN SL
Material: Stainless Steel, Cast Iron, Cast Iron(1)
PRODUCT_PROPERTIES - 01 Producto: Fuente Ges: Ges-UM560-1M-1020mm
