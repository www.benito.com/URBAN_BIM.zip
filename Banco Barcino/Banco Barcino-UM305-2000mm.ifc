Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T12:36:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 12:36:00 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\7166d65d-2c04-41a1-8b28-784ec8abd0b6\4ba75c93-47c2-43d3-ba58-77f0937b34ec\ifc * Database version: 5507 * Database creation date: Tue Mar 07 12:35:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 12:35:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 12:35:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Barcino:Banco Barcino-UM305-2000mm, Banco Barcino:Banco Barcino-UM305-2000mm:402757
In: Level 1
Type - Material: Fundición dúctil
Type - PRODUCT_PROPERTIES - 02 Material Pies: Fundición dúctil; 02 Material Tablones: Madera trópical; 03 Dimension_A: 2 m; 03 Dimension_H: 0.785 m; 03 Dimension_H1: 0.44 m; 03 Dimension_B: 0.7 m; 04 Descripción: El BARCINO es un banco fabricado con pies de fundición dúctil y tablones de madera trópical; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM305; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/barcino--UM3031.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM3031; 09 Fabricante: BENITO URBAN SL
Material: Fundición dúctil, Madera trópical
PRODUCT_PROPERTIES - 01 Producto: Banco Barcino: Banco Barcino-UM305-2000mm
