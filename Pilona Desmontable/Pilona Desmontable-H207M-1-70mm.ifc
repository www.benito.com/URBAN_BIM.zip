Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T13:14:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 13:14:45 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\653d792b-491d-4c66-8957-3e193aeee637\ifc * Database version: 5507 * Database creation date: Wed Apr 05 13:14:43 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 13:14:45 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 13:14:45 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Desmontable:Pilona Desmontable-H207M-1-70mm, Pilona Desmontable:Pilona Desmontable-H207M-1-70mm:868793
In: Level 1
Type - Material: Steel(2)
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.07 m; 03 Dimension_H: 0.99 m; 03 Dimension_H1: 0.21 m; 04 Descripción: Pilona fabricada en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: n/a; 06 Referencia: H207M; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/desmontable--H207M.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H207M; 09 Fabricante: BENITO URBAN SL
Material: Steel(2), Steel(1), Steel, <Unnamed>
PRODUCT_PROPERTIES - 01 Producto: Pilona Desmontable: Pilona Desmontable-H207M-1-70mm
