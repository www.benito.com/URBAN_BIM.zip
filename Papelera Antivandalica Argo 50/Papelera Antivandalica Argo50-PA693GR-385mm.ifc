Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T19:35:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 19:35:19 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\9c9e37f3-9a28-460b-9e27-644fa469dead\ifc * Database version: 5507 * Database creation date: Tue Mar 07 19:35:16 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 19:35:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 19:35:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Antivandalica Argo 50:Papelera Antivandalica Argo 50-PA693GR-385mm, Papelera Antivandalica Argo 50:Papelera Antivandalica Argo 50-PA693GR-385mm:460456
In: Level 1
Type - Material: Galvanized Steel
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0.385 m; 03 Dimension_H: 0.825 m; 03 Dimension_H1: 0.485 m; 03 Dimension_B: 0.385 m; 04 Descripción: La Papelera antivandálica Argo 50 combina en armonía una máxima funcionalidad, resistencia y atractivo diseño, resultando una propuesta óptima para espacios públicos contemporáneos.; 05 Información_Adicional: Su sencillez en el proceso de vaciado y un interior de acero galvanizado hacen de ella un producto completo; 06 Referencia: PA693GR; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/antivandalica-argo-50--PA693GR.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA693GR; 09 Fabricante: BENITO URBAN SL
Material: Galvanized Steel, <Unnamed>
PRODUCT_PROPERTIES - 01 Producto: Papelera Antivandalica Argo 50: Papelera Antivandalica Argo 50-PA693GR-385mm
