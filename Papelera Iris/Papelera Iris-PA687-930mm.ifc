Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T20:19:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 20:19:36 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\8cefb784-04ad-4699-b0b6-4d9111e775d6\4c152dda-1b16-430d-af07-8c49655b43a5\ifc * Database version: 5507 * Database creation date: Tue Mar 07 20:19:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 20:19:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 20:19:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Iris:Paperela Iris-PA687-930mm, Papelera Iris:Paperela Iris-PA687-930mm:470131
In: Level 1
Type - Material: PA687
Type - PRODUCT_PROPERTIES - 02 Material: Polimero; 03 Dimension_A: 0.56 m; 03 Dimension_H: 0.93 m; 03 Dimension_B: 0.4 m; 03 Dimension_C: 0.22 m; 04 Descripción: Fabricada en rotomoldeo. Alta resistencia a condiciones ambientales extremas y antivandálica; 05 Información_Adicional: Anclaje recomendado: Pieza de anclaje para suelo blando, pieza de anclaje para suelo duro o mediante bridas.; 06 Referencia: PA687; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/iris--PA687.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA687A; 09 Fabricante: BENITO URBAN SL
Material: <Unnamed>, PA687, PVC
PRODUCT_PROPERTIES - 01 Producto: Papelera Iris: Paperela Iris-PA687-930mm
