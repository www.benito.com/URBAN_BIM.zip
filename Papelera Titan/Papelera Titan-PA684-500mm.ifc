Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T21:55:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 21:55:20 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\75b1fc97-0797-4b2b-ae47-52cde66e3648\ifc * Database version: 5507 * Database creation date: Fri Mar 10 21:55:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 21:55:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 21:55:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Paperela Titan:Paperela Titan-PA684-500mm, Paperela Titan:Paperela Titan-PA684-500mm:696589
In: Level 1
Type - Material: Steel Switch Titan
Type - PRODUCT_PROPERTIES - 02 Material: Acero zincado; 03 Dimension_A: 0.5 m; 03 Dimension_H: 1.025 m; 03 Dimension_H1: 0.8 m; 03 Dimension_B: 0.32 m; 04 Descripción: Cubeta y tapa en acero zincado. Sistema interior con aro sujeta-bolsas, tapa superior y puerta frontal. Cenicero incorporado y desmontable; 05 Información_Adicional: Anclaje recomendado: Fijación al suelo mediante 4 tornillos Ø10, no suministrados.; 06 Referencia: PA684; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/titan--PA684.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA684; 09 Fabricante: BENITO URBAN SL
Material: Steel Switch Titan, Steel Titan
PRODUCT_PROPERTIES - 01 Producto: Paperela Titan: Paperela Titan-PA684-500mm
