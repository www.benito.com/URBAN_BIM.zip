Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T10:56:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 10:56:33 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\a9c34a21-9a65-49ef-8549-807173b8eaa3\4fb82815-fc58-4d06-9be2-50279e007137\ifc * Database version: 5507 * Database creation date: Tue Feb 21 10:56:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 10:56:32 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 10:56:32 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Aparcapatinetes Patin:Aparcapatinetes Patin-VBP05-970mm, Aparcapatinetes Patin:Aparcapatinetes Patin-VBP05-970mm:277874
In: Level 1
Type - Material: Acero galvanizado
Type - PRODUCT_PROPERTIES - 02 Material: Acero galvanizado; 03 Dimension_A: 0.97 m; 03 Dimension_H: 0.66 m; 03 Dimension_B: 0.2 m; 04 Descripción: Material en acero galvanizado. Acabado con una capa de imprimación epoxi y pintura poliéster especial para exteriores.; 05 Información_Adicional: Fijación al suelo mediante 8 tornillos M8, no suministrados.; 06 Referencia: VBP05; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/aparcabicicletas/patin--VBP05.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBP05; 09 Fabricante: BENITO URBAN SL
Material: Acero galvanizado, Acero galvanizado con pintura poliester
PRODUCT_PROPERTIES - 01 Producto: Aparcapatinetes Patin: Aparcapatinetes Patin-VBP05-970mm
