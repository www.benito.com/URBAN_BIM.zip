Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T19:47:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 19:47:26 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\ffb68c9d-5ff2-4fb1-bdf3-cc7220ec950e\ifc * Database version: 5507 * Database creation date: Fri Apr 21 19:47:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 19:47:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 19:47:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Reductores Velocidad Slow 600x30:Reductores Velocidad Slow 600x30-VBA04-600mm, Reductores Velocidad Slow 600x30:Reductores Velocidad Slow 600x30-VBA04-600mm:892526
In: Level 1
Type - Material: Natural Rubber
Type - PRODUCT_PROPERTIES - 03 Dimension_B: 0 m; 02 Material: 100% reciclable y ecológico; 03 Dimension_A: 0.6 m; 03 Dimension_H: 0.03 m; 04 Descripción: Reductor de velocidad de 30 mm de altura para vías públicas con límite de velocidad máxima 50Km/h; 05 Información_Adicional: Anclaje recomendado: Mediante tornillos M8 y anclaje plástico. (no subministrados); 06 Referencia: VBA04; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/reductores-de-velocidad/slow-600-x-30--VBA01.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBA01; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Reductores Velocidad Slow 600x30: Reductores Velocidad Slow 600x30-VBA04-600mm
