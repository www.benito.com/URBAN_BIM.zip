Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T12:50:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 12:50:55 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\fc902aa1-24cd-4598-b926-14f46f50c2d8\9d3e28b5-1ff0-4a03-8a7d-70f6018eb4a7\ifc * Database version: 5507 * Database creation date: Fri Mar 10 12:50:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 12:50:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 12:50:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Roda:Banco Roda-UM302-1995mm, Banco Roda:Banco Roda-UM302-1995mm:574936
In: Level 1
Type - Material: Ductile Iron
Type - PRODUCT_PROPERTIES - 02 Material Pies: Fundición dúctil; 02 Material Tablones: Madera trópical; 03 Dimension_A: 1.995 m; 03 Dimension_H: 0.75 m; 03 Dimension_H1: 0.415 m; 03 Dimension_B: 0.62 m; 04 Descripción: Banco fabricado con pies de fundición dúctil tratado con Ferrus; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto.; 06 Referencia: UM320; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/roda--UM320.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM320; 09 Fabricante: BENITO URBAN SL
Material: Ductile Iron, Wood
PRODUCT_PROPERTIES - 01 Producto: Banco Roda: Banco Roda-UM302-1995mm
