Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T20:10:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 20:10:48 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\04a15c49-9b71-43ba-bace-299b1a6d654f\ifc * Database version: 5507 * Database creation date: Fri Apr 21 20:10:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 20:10:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 20:10:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Rustica Plana:Valla Rustica Plana-VRV470R-1170mm, Valla Rustica Plana:Valla Rustica Plana-VRV470R-1170mm:903057
In: Level 1
Type - Material: Wood
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 1.95 m; 03 Dimension_H: 1.17 m; 03 Dimension_H1: 0.7 m; 03 Dimension_D: 0.09 m; 04 Descripción: Valla fabricada en madera de pino con tratamiento autoclave a vacío-presión clase 4 contra la carcoma, termitas e insectos. Postes verticales de 1170 x 90 mm. Lamas con cantos redondeados; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón.; 06 Referencia: VRV470R; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/rustica-plana--VRV470R.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRV470R; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Rustica Plana: Valla Rustica Plana-VRV470R-1170mm
