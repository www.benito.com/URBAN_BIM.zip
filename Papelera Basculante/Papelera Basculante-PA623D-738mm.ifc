Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T19:50:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 19:50:48 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\03e488bf-a1f3-4520-9928-9de0999d221b\ifc * Database version: 5507 * Database creation date: Fri Mar 10 19:50:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 19:50:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 19:50:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Basculante:Papelera Basculante-PA623D-738mm, Papelera Basculante:Papelera Basculante-PA623D-738mm:673093
In: Level 1
Type - Material: Basculante PA623D
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.738 m; 03 Dimension_H: 1.465 m; 03 Dimension_H1: 0.46 m; 03 Dimension_B: 0.32 m; 04 Descripción: Papelera fabricada con cubetas cilíndricas de plancha embutidas y poste de Ø 60 mm de acero con tratamiento Ferrus; 05 Información_Adicional: Anclaje recomendado: Mediante empotramiento en el suelo.; 06 Referencia: PA623D; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/basculante-doble--PA623D.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA623D; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Papelera Basculante: Papelera Basculante-PA623D-738mm
