Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-09T19:01:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 09 19:01:29 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\cc423866-564d-4475-9481-d6d540063435\9d0a740c-929f-4201-af79-4a7a22b95c34\ifc * Database version: 5507 * Database creation date: Thu Mar 09 19:01:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 09 19:01:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 09 19:01:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Picco:Papelera Picco-PA664S2-1135mm, Papelera Picco:Papelera Picco-PA664S2-1135mm:556527
In: Level 1
Type - Material: Gi Steel
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 1.135 m; 03 Dimension_H: 1 m; 03 Dimension_H1: 0.785 m; 03 Dimension_B: 0.57 m; 04 Descripción: Papelera fabricada en madera de pino con tratamiento autoclave a vacío-presión clase 4 contra la carcoma, termitas e insectos.; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión de M8.; 06 Referencia: PA664S2; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/picco-2--PA664S2.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA664S2; 09 Fabricante: BENITO URBAN SL
Material: Gi Steel, Wood
PRODUCT_PROPERTIES - 01 Producto: Papelera Picco: Papelera Picco-PA664S2-1135mm
