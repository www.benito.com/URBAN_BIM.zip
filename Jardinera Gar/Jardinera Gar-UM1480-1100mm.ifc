Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-22T21:17:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 21:17:40 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\a90df35c-1758-4146-86b0-fd69ab5f04b1\2c2a99d7-b396-4ba6-8493-6f6a52d0feb7\ifc * Database version: 5507 * Database creation date: Wed Mar 22 21:17:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 21:17:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 21:17:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Gar:Jardinera Gar-UM1480-1100mm, Jardinera Gar:Jardinera Gar-UM1480-1100mm:705901
In: Level 1
Type - Material: Rebnew (5)
Type - PRODUCT_PROPERTIES - 02 Material: Rebnew; 03 Dimension_A: 1.1 m; 03 Dimension_H: 0.475 m; 03 Dimension_B: 0.7 m; 04 Descripción: Jardinera fabricada con plástico reciclado Rebnew, un material excepcional.; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso.; 06 Referencia: UM1480; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/gar--UM1480.html?gclid=CjwKCAjwzuqgBhAcEiwAdj5dRuUjmDwDWn38ps_3I2yirde0eqzXU9MNG1RzuUvBo_gjp3nIC9PmNhoCLp8QAvD_BwE; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1480; 09 Fabricante: BENITO URBAN SL.
PRODUCT_PROPERTIES - 01 Producto: Jardinera Gar: Jardinera Gar-UM1480-1100mm
