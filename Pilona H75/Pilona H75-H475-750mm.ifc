Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T22:25:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.1.0.1 - Alternate UI 20.1.0.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 22:25:27 2023 * Host: Cristina_CIBIM * Database: C:\Users\CIBIM\AppData\Local\Temp\24aa930e-4ed6-4ff3-bbc9-eb55fbe84bac\2013df4c-8a02-41bd-ad0e-94400a99e30c\ifc * Database version: 5507 * Database creation date: Fri Apr 21 22:25:27 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 22:25:27 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 22:25:27 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona H75:Pilona H75-H475-750mm, Pilona H75:Pilona H75-H475-750mm:911917
In: Level 1
Type - Material: PVC Blue
Type - PRODUCT_PROPERTIES - 02 Material: Polietilieno; 03 Dimension_A: 0.2 m; 03 Dimension_H: 0.75 m; 04 Descripción: Pilona fabricada en polietileno de alta calidad y máxima flexibilidad que le permite soportar grandes impactos, ya que posee unas elevadas propiedades de memoria de forma y resistencia y un excelente comportamiento a los rayos solares ultravioletas, gracias al aditivo Anti-UV que lleva incorporado.; 06 Referencia: H475; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/h75--H475.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H475; 09 Fabricante: BENITO URBAN SL
Material: PVC Blue, PVC W St
PRODUCT_PROPERTIES - 01 Producto: Pilona H75: Pilona H75-H475-750mm
