Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-28T13:02:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 28 13:02:49 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\3c79c539-4885-4fcd-bc65-b27275f692d0\e6661000-1e3b-465f-8070-37d0dd915a65\ifc * Database version: 5507 * Database creation date: Tue Mar 28 13:02:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 28 13:02:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 28 13:02:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Olea:Jardinera Olea-UM1220-750mm, Jardinera Olea:Jardinera Olea-UM1220-750mm:763389
In: Level 1
Type - Material: <Unnamed>, Acero corten (5)
Type - PRODUCT_PROPERTIES - 02 Material: Acero corten; 03 Dimension_A: 0.75 m; 03 Dimension_H: 0.75 m; 03 Dimension_B: 0.75 m; 04 Descripción: Jardinera fabricada en chapa de acero corten, concebida para permanecer en el tiempo sin ningún tipo de mantenimiento. No necesita ningún acabado, evita procesos contaminantes y contribuye a la sostenibilidad medioambiental.; 05 Información_Adicional: La oxidación del acero corten evoluciona con el paso del tiempo y se oxida, más o menos rápido, en función de la temperatura ambiente y la humedad.; 06 Referencia: UM1220; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/olea--UM1220.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1220; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Olea: Jardinera Olea-UM1220-750mm
