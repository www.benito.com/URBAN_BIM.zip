Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T18:45:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 18:45:49 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\2ce84f92-5da6-4309-968e-3c183a5acc3b\ifc * Database version: 5507 * Database creation date: Fri Mar 10 18:45:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 18:45:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 18:45:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Salou:Papelera Salou-PA641-460mm, Papelera Salou:Papelera Salou-PA641-460mm:647620
In: Level 1
Type - Material: Wood
Type - PRODUCT_PROPERTIES - 02 Material: Madera trópical; 03 Dimension_A: 0.46 m; 03 Dimension_H: 0.7 m; 03 Dimension_H1: 0.545 m; 04 Descripción: Papelera fabricada con estructura interior metálica y exterior con veinticuatro listones de madera tropical de sección 40 x 35 mm tratada con el recubrimiento de triple capa con Lignus, protector fungicida, insecticida e hidrófugo.; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión de M8 según superficie y proyecto.; 06 Referencia: PA641; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/salou--PA641.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA641; 09 Fabricante: BENITO URBAN SL
Material: Wood, Concrete, Steel
PRODUCT_PROPERTIES - 01 Producto: Papelera Salou: Papelera Salou-PA641-460mm
