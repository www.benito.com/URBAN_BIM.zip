Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T22:16:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 22:16:10 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2306e0ad-f087-4bcf-9211-598b6fcefd24\a7f48342-8e78-47a5-a343-2c9301cc185b\ifc * Database version: 5507 * Database creation date: Tue Feb 21 22:16:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 22:16:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 22:16:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Semiautomatica_L:Pilona Semiautomatica-H220L4-220mm, Pilona Telescopica Semiautomatica_L:Pilona Semiautomatica-H220L4-220mm:367685
In: Level 1
Type - Material: <Unnamed>, LED Rojo, Acero inoxidable, Acero galvanizado
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.22 m; 03 Dimension_H: 1.17 m; 03 Dimension_H1: 0.67 m; 03 Dimension_B: 0.274 m; 03 Dimension_C: 0.34 m; 03 Dimension_D: 0.5 m; 03 Dimension_Espesor: 0.004 m; 04 Descripción: Pilona diseñada para control de acceso en la vía pública, en comunidades, empresas, etc; 05 Información_Adicional: Elevación automática, fácil y rápida, bajada manual. Bloqueo automático tanto en posición subida como bajada, desbloqueo mediante llave triangular DIN3223.; 06 Referencia: H220L8; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-semiautomatica-con-llave-y-led-%C3%98220-x-500--H220L8.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H220L8; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Semiautomatica_L: Pilona Semiautomatica-H220L4-220mm
