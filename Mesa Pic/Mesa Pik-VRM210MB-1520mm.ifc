Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:19:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:19:46 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\2074405b-d607-4a06-b3fc-7f0b0247219a\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:19:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:19:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:19:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Mesa Pik:Mesa Pik-VRM210MB-1520mm, Mesa Pik:Mesa Pik-VRM210MB-1520mm:973998
In: Level 1
Type - Material: Rebnew
Type - PRODUCT_PROPERTIES - 02 Material: Rebnew; 03 Dimension_A: 1.52 m; 03 Dimension_H: 0.77 m; 03 Dimension_H1: 0.44 m; 03 Dimension_B: 1.8 m; 04 Descripción: Mesa de Picnic de Tablones Rebnew con refuerzo metálico de 110 x 40 x 1800. Excelente comportamiento en el exterior, mesa robusta y de gran firmeza perdurable con el paso de los años. Sin mantenimiento. Resistencia a la intemperie. Resistente a aceites, ácidos y agua de mar. No se degrada; 06 Referencia: VRM210MB; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/mesas/pik--VRM210MB.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRM210MB; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Mesa Pik: Mesa Pik-VRM210MB-1520mm
