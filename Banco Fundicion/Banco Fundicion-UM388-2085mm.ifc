Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-10T19:24:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 10 19:24:23 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f194ae38-e11d-4cf4-8f3d-d12916065b10\a9c20166-66a0-4a27-9c1e-edbb46a68d38\ifc * Database version: 5507 * Database creation date: Fri Mar 10 19:24:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 10 19:24:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 10 19:24:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Fundicion:Banco Fundicion-UM388-2085mm, Banco Fundicion:Banco Fundicion-UM388-2085mm:661173
In: Level 1
Type - Material: Ductile Iron
Type - PRODUCT_PROPERTIES - 02 Material: Fundición dúctil; 03 Dimension_A: 2.085 m; 03 Dimension_H: 0.8 m; 03 Dimension_H1: 0.4 m; 03 Dimension_B: 0.59 m; 04 Descripción: Banco fabricado con pies, respaldo y asiento de fundición dúctil tratado con Ferrus; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión M10 según superficie y proyecto; 06 Referencia: UM388; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/fundicion--UM388.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM388; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Fundicion: Banco Fundicion-UM388-2085mm
