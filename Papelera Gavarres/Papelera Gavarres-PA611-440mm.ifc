Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T14:38:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 14:38:50 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\4882b719-f524-4ecf-8d61-df90bf8730c1\ifc * Database version: 5507 * Database creation date: Sat Apr 22 14:38:48 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 14:38:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 14:38:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Gavarres:Papelera Gavarres-PA611-440mm, Papelera Gavarres:Papelera Gavarres-PA611-440mm:1001091
In: Level 1
Type - Material: Corten Steel(1)
Type - PRODUCT_PROPERTIES - 02 Material: Acero corten; 03 Dimension_A: 0.44 m; 03 Dimension_H: 1 m; 03 Dimension_H1: 0.67 m; 03 Dimension_B: 0.46 m; 04 Descripción: Papelera fabricada con estructura de acero corten de 6 mm. Con tablones de madera de pino tratada en autoclave vacío-presión clase 4 contra la carcoma, termitas e insectos. Cubeta interior de acero galvanizado; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión según superficie y proyecto.; 06 Referencia: PA611; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/gavarres--PA611.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA611; 09 Fabricante: BENITO URBAN SL
Material: Corten Steel(1), Madera de pino, Acero corten, Wood, <Unnamed>
PRODUCT_PROPERTIES - 01 Producto: Papelera Gavarres: Papelera Gavarres-PA611-440mm
