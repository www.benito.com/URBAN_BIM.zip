Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T13:00:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 13:00:31 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\7166d65d-2c04-41a1-8b28-784ec8abd0b6\14794e25-101d-4f2d-92c6-1a0a95c1e283\ifc * Database version: 5507 * Database creation date: Tue Mar 07 13:00:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 13:00:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 13:00:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Toledo:Banco Toledo-UM370-2000mm, Banco Toledo:Banco Toledo-UM370-2000mm:430721
In: Level 1
Type - Material: Precast Concrete
Type - PRODUCT_PROPERTIES - 03 Dimension_H1: 0 m; 02 Material: Hormigón prefabricado; 03 Dimension_A: 2 m; 03 Dimension_H: 0.425 m; 03 Dimension_B: 0.45 m; 04 Descripción: Banco fabricado en hormigón prefabricado armado color blanco granítico; 05 Información_Adicional: Anclaje recomendado: Apoyado en el suelo en sus extremos robustos con el objetivo de facilitar la limpieza y el mantenimiento.; 06 Referencia: UM370; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/toledo--UM370.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM370; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Toledo: Banco Toledo-UM370-2000mm
