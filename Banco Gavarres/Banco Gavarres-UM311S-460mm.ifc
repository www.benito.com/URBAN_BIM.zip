Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:49:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:49:20 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\75899abe-402d-48c7-8646-aedb0d0e8971\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:49:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:49:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:49:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Gavarres Banqueta:Gavarres Banqueta-UM311S-460mm, Gavarres Banqueta:Gavarres Banqueta-UM311S-460mm:988387
In: Level 1
Type - Material: Wood (7), Casr Iron (9)
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 0.46 m; 03 Dimension_H: 0.81 m; 03 Dimension_H1: 0.5 m; 03 Dimension_B: 0.44 m; 04 Descripción: Banco fabricado con pies en plancha de acero corten de 8 mm.. Tablones de sección 210 x 58 mm fabricados en madera de pino tratada en autoclave vacío-presión clase 4 contra la carcoma, termitas e insectos.; 06 Referencia: UM311S; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/taburete-sistema-modular-gavarres--UM311S.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM311S; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Gavarres Banqueta: Gavarres Banqueta-UM311S-460mm
