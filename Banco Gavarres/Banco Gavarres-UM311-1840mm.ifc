Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T13:51:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 13:51:48 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\19fca66b-504b-49ff-b8a1-a760111bda2a\ifc * Database version: 5507 * Database creation date: Sat Apr 22 13:51:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 13:51:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 13:51:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Gavarres Banqueta:Gavarres Banqueta-UM311-1840mm, Gavarres Banqueta:Gavarres Banqueta-UM311-1840mm:988387
In: Level 1
Type - Material: Casr Iron (6), Wood (6)
Type - PRODUCT_PROPERTIES - 02 Material: Madera de pino; 03 Dimension_A: 1.84 m; 03 Dimension_H: 0.81 m; 03 Dimension_H1: 0.5 m; 03 Dimension_B: 0.575 m; 04 Descripción: Banco fabricado con pies en plancha de acero corten de 8 mm.. Tablones de sección 210 x 58 mm fabricados en madera de pino tratada en autoclave vacío-presión clase 4 contra la carcoma, termitas e insectos; 05 Información_Adicional: Anclaje recomendado: Mediante pernos de expansión superficie y proyecto.; 06 Referencia: UM311; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/gavarres--UM311.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM311; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Gavarres Banqueta: Gavarres Banqueta-UM311-1840mm
