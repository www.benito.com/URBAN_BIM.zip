Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-03T18:13:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 03 18:13:01 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\edb5124a-c271-4f6d-80d6-7ecb8aa65f7f\40ba833e-71aa-44aa-b884-e5368c13dcd1\ifc * Database version: 5507 * Database creation date: Mon Apr 03 18:12:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 03 18:13:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 03 18:13:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Hospitalet Durable:Pilona Hospitalet Durable-H214FM, Pilona Hospitalet Durable:Pilona Hospitalet Durable-H214FM:776753
In: Level 1
Type - Material: Steel Bottom
Type - PRODUCT_PROPERTIES - 02 Material: Composite alta resistencia; 03 Dimension_A: 0.095 m; 03 Dimension_H: 1 m; 04 Descripción: Pilona fabricada en composite de alta resistencia al impacto 100% reciclable, con anillo de acero inoxidable en la parte superior. Acabado satinado, color negro forja; 05 Información_Adicional: Anclaje recomendado: Base empotrable.; 06 Referencia: H214FM; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-semiflexibles/hospitalet-durable-mobil--H214FM.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H214FM; 09 Fabricante: BENITO URBAN SL
Material: Steel Bottom, Steel H214F, Glass H214F
PRODUCT_PROPERTIES - 01 Producto: Pilona Hospitalet Durable: Pilona Hospitalet Durable-H214FM
