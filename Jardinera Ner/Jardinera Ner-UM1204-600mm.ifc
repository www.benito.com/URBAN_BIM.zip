Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-24T14:10:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 24 14:10:18 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dae11e8c-7099-491a-aeb2-759fd5724457\ed6654ca-3d08-4825-b8c3-7add0b0efd2a\ifc * Database version: 5507 * Database creation date: Fri Mar 24 14:10:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 24 14:10:17 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 24 14:10:17 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Jardinera Ner:Jardinera Ner-UM1204-600mm, Jardinera Ner:Jardinera Ner-UM1204-600mm:733680
In: Level 1
Type - Material: Steel Sheet
Type - PRODUCT_PROPERTIES - 02 Material: Acero corten; 03 Dimension_A: 0.6 m; 03 Dimension_H: 0.78 m; 03 Dimension_B: 0.6 m; 04 Descripción: Jardinera fabricada en chapa de acero corten, concebida para permanecer en el tiempo sin ningún tipo de mantenimiento; 06 Referencia: UM1204; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/jardineras/ner--UM1204.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM1204; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Jardinera Ner: Jardinera Ner-UM1204-600mm
