Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-07T10:45:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 10:45:49 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\7166d65d-2c04-41a1-8b28-784ec8abd0b6\b2d3ef7c-5e97-45fb-a072-00bdd8cc6fe9\ifc * Database version: 5507 * Database creation date: Tue Mar 07 10:45:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 10:45:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 10:45:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Papelera Argo Plus:Papelera Argo Plus-PA692SGRH-1025mm, Papelera Argo Plus:Papelera Argo Plus-PA692SGRH-1025mm:390129
In: Level 1
Type - Material: Acero
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 0.4 m; 03 Dimension_H: 1.025 m; 03 Dimension_H1: 0.785 m; 03 Dimension_B: 0.4 m; 04 Descripción: Papelera fabricada con cubeta de acero reforzada con ventanillas; 05 Información_Adicional: Anclaje recomendado: Mediante tres pernos de expansión M8 según superficie y proyecto; 06 Referencia: PA692SGRH; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/papeleras/argo-plus--PA692SGRH.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-PA692SGRH; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Papelera Argo Plus: Papelera Argo Plus-PA692SGRH-1025mm
