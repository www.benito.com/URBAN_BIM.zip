Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T20:17:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 20:17:40 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\6909bad0-4c96-43e4-9b3e-968df2fcb127\ifc * Database version: 5507 * Database creation date: Fri Apr 21 20:17:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 20:17:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 20:17:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Nudo:Valla Nudo-VVP008-300mm, Valla Nudo:Valla Nudo-VVP008-300mm:907416
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 03 Dimension_A: 0 m; 02 Material: Acero Ferrus; 03 Dimension_H: 0.3 m; 04 Descripción: Valla fabricada íntegramente en acero Ø16 mm y pletina 30 x 6 mm, con estructura reforzada tratada con Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante anclaje en hormigón; 06 Referencia: VVP008; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/nudo--VVP009.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VVP009; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Nudo: Valla Nudo-VVP008-300mm
