Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-28T13:24:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 28 13:24:10 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\964346be-f97f-48f7-9cea-14bcfe9f57b9\aaad0e2e-0041-47a5-85c5-b8980c451253\ifc * Database version: 5507 * Database creation date: Tue Feb 28 13:24:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 28 13:24:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 28 13:24:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Estacion Mantenimiento Biki:Estación Mantenimiento Biki-VBE01-1500mm, Estacion Mantenimiento Biki:Estación Mantenimiento Biki-VBE01-1500mm:379344
In: Level 1
Type - Material: Steel
Type - PRODUCT_PROPERTIES - 02 Material: Acero con pintura; 03 Dimension_A: 0.22 m; 03 Dimension_H: 1.5 m; 04 Descripción: La estación incluye varias herramientas como una bomba de pie de aire para inflar las ruedas, llaves hexagonales allen de diferentes tamaños, llave inglesa, alicates, destornillador plano y de estrella y palancas para sacar la cubierta de la rueda.; 05 Información_Adicional: Fijación al suelo mediante 4 tornillos M8, no suministrados.; 06 Referencia: VBE01; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/aparcabicicletas/estacion-de-mantenimiento-biki--VBE01.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBE01
Material: Steel, Steel, Paint Finish, Green
PRODUCT_PROPERTIES - 01 Producto: Estacion Mantenimiento Biki: Estación Mantenimiento Biki-VBE01-1500mm
