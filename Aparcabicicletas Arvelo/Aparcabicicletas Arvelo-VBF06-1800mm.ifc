Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-18T22:06:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Feb 18 22:06:10 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\69448132-8513-48c7-867b-620cdacfdb02\17dff8cf-1a83-42c9-b4c5-664140915d12\ifc * Database version: 5507 * Database creation date: Sat Feb 18 22:06:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Feb 18 22:06:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Feb 18 22:06:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Aparcabicicletas Arvelo:Aparcabicicletas Arvelo-VBF06-1800mm, Aparcabicicletas Arvelo:Aparcabicicletas Arvelo-VBF06-1800mm:262800
In: Level 1
Type - Material: Acero galvanizado
Type - PRODUCT_PROPERTIES - 02 Material: Acero galvanizado; 03 Dimension_A: 1.8 m; 03 Dimension_H: 0.5 m; 03 Dimension_B: 0.55 m; 03 Dimension_C: 0.35 m; 04 Descripción: Aparcabicis fabricado en acero galvanizado en caliente.; 05 Información_Adicional: Anclaje: Mediante pernos de expansión M8, según superficie y proyecto; 06 Referencia: VBF06; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/aparcabicicletas/arvelo--VBF06.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBF06; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Aparcabicicletas Arvelo: Aparcabicicletas Arvelo-VBF06-1800mm
