Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-04T18:47:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 04 18:47:01 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f1d4468b-d284-46e3-a685-101460c63c71\4efbb792-98a4-452b-9d03-c4ef18b84bcc\ifc * Database version: 5507 * Database creation date: Tue Apr 04 18:46:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 04 18:47:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 04 18:47:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Banco Petrus:Banco Petrus-UM359-1640mm, Banco Petrus:Banco Petrus-UM359-1640mm:800524
In: Level 1
Type - Material: Precast Concrete
Type - PRODUCT_PROPERTIES - 03 Dimension_H1: 0 m; 02 Material: Hormigón prefabricado; 03 Dimension_A: 1.64 m; 03 Dimension_H: 0.47 m; 03 Dimension_B: 0.61 m; 04 Descripción: Banco fabricado en hormigón prefabricado color gris granítico de aspecto rugoso. Se puede colocar en elementos aislados o en grupos; 05 Información_Adicional: Anclaje recomendado: Apoyado por su propio peso.; 06 Referencia: UM359; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bancos/petrus--UM359.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM359; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Banco Petrus: Banco Petrus-UM359-1640mm
