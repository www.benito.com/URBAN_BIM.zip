Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T22:10:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 22:10:07 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2f8606de-99a2-4c36-9cb6-317b96044032\143374c1-8b21-4841-8ffa-5c231e244c70\ifc * Database version: 5507 * Database creation date: Fri Apr 21 22:10:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 22:10:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 22:10:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Alcorque Taulat:Alcorque Taulat-A27A-1195mm, Alcorque Taulat:Alcorque Taulat-A27A-1195mm:929441
In: Level 1
Type - Material: Steel (2)
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 1.195 m; 03 Dimension_H: 0.04 m; 03 Dimension_B: 1.195 m; 03 Dimension_D: 0.47 m; 04 Descripción: Alcorque fabricado en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión; 05 Información_Adicional: A25A con 3 aberturas circulares. A26A, A27A y A29A con 4 aberturas circulares.; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/alcorques/taulat--A27A.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-A27A; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Alcorque Taulat: Alcorque Taulat-A27A-1195mm
