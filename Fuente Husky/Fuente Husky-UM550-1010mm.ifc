Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-04T18:53:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 04 18:53:03 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\f1d4468b-d284-46e3-a685-101460c63c71\ea1a17b9-2098-4d54-8f26-16b2107c1d05\ifc * Database version: 5507 * Database creation date: Tue Apr 04 18:53:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 04 18:53:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 04 18:53:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Fuente Husky:Fuente Husky-UM550-100mm, Fuente Husky:Fuente Husky-UM550-100mm:813879
In: Level 1
Type - Material: Stainless Steel(1)
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.3 m; 03 Dimension_H: 1.01 m; 03 Dimension_B: 0.5 m; 04 Descripción: Fuente con 2 grifos pulsadores a dos alturas, uno adaptado para perros.; 05 Información_Adicional: Cuerpo fabricado en acero con tratamiento Ferrus, proceso protector del hierro que garantiza una óptima resistencia a la corrosión.; 06 Referencia: UM550; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/fuentes/husky--UM550.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-UM550; 09 Fabricante: BENITO URBAN SL
Material: Stainless Steel(1), <Unnamed>, Stainless Steel
PRODUCT_PROPERTIES - 01 Producto: Fuente Husky: Fuente Husky-UM550-100mm
