Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-05T10:19:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 05 10:19:21 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\dfaf820a-fd5b-4ce3-a8f6-aefcc5495189\2f1bc0b9-8838-4d33-9e1d-d9cce8c245de\ifc * Database version: 5507 * Database creation date: Wed Apr 05 10:19:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 05 10:19:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 05 10:19:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Universal:Pilona Universal-H211AP-300mm, Pilona Universal:Pilona Universal-H211AP-300mm:815204
In: Level 1
Type - Material: Universal
Type - PRODUCT_PROPERTIES - 02 Material: Acero Ferrus; 03 Dimension_A: 0.3 m; 03 Dimension_H: 0.41 m; 03 Dimension_B: 0.2 m; 04 Descripción: Pilona fabricada en acero con tratamiento Ferrus; 05 Información_Adicional: n/a; 06 Referencia: H211AP; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/bolardos-pilonas/universal--H211AP.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H211AP; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Universal: Pilona Universal-H211AP-300mm
