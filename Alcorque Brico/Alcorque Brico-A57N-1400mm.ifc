Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-17T17:10:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 17 17:10:30 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\59ecc31a-a08b-4f84-ba49-bfe6638f4015\65698be9-ca8f-4d87-8fd6-e127cd9c4bcb\ifc * Database version: 5507 * Database creation date: Fri Feb 17 17:10:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 17 17:10:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 17 17:10:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Alcorque Brico:Alcorque Brico-A57N-1400mm, Alcorque Brico:Alcorque Brico-A57N-1400mm:213339
In: Level 1
Type - Material: Fundición dúctil (4)
Type - PRODUCT_PROPERTIES - 02 Material: Fundición dúctil; 03 Dimension_A: 1.4 m; 03 Dimension_H: 0.2 m; 03 Dimension_B: 1.4 m; 04 Descripción: Alcorque fabricado en fundición dúctil sin pintar (oxidado).; 05 Información_Adicional: Anclaje recomendado: Auto-anclaje con tornillos y cimentación.; 06 Referencia: A57N; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/homologados-barcelona/brico--A57N.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-A57N; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Alcorque Brico: Alcorque Brico-A57N-1400mm
