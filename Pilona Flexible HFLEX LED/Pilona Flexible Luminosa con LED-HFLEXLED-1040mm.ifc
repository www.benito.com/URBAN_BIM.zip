Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-21T18:58:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.1.0.1 - Alternate UI 20.1.0.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 21 18:58:23 2023 * Host: Cristina_CIBIM * Database: C:\Users\CIBIM\AppData\Local\Temp\24aa930e-4ed6-4ff3-bbc9-eb55fbe84bac\1f87ebe2-998f-4131-b929-3da1cb0ee128\ifc * Database version: 5507 * Database creation date: Fri Apr 21 18:58:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 21 18:58:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 21 18:58:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Flexible Luminosa Con LED:Pilona Flexible Luminosa Con LED-HFLEXLED-1040mm, Pilona Flexible Luminosa Con LED:Pilona Flexible Luminosa Con LED-HFLEXLED-1040mm:883915
In: Level 1
Type - Material: Aluminium
Type - PRODUCT_PROPERTIES - 02 Material: Poliuretano flexible; 03 Dimension_A: 0.1 m; 03 Dimension_H: 1.04 m; 03 Dimension_H1: 0.19 m; 04 Descripción: Pilona luminosa con LED, fabricada en poliuretano flexible en color negro (opcional en rojo, verde, amarillo o azul), resistente a los rayos UV, con una banda reflectante; 05 Información_Adicional: Se fabrica en variante fija o móvil con bases de poliuretano o de acero inoxidable. También en versión con peana para instalación atornillada. Supera una flexión de 1500 ciclos a 45º y 50 ciclos a 90º, sin daños. Clasificación “E” de comportamiento al fuego, según norma UNE-EN 13501-1:2007+A1:2010. Resistente a -50º según norma UNE ISO 812. Anclaje recomendado: Mediante encastamiento.; 06 Referencia: HFLEXLED; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/pilonas-flexibles/flexible-luminosa-con-led--HFLEXLED.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-HFLEXLED; 09 Fabricante: BENITO URBAN SL
Material: Aluminium, LED verde, Poliuretano flexible
PRODUCT_PROPERTIES - 01 Producto: Pilona Flexible Luminosa Con LED: Pilona Flexible Luminosa Con LED-HFLEXLED-1040mm
