Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-21T20:02:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 20:02:15 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\2306e0ad-f087-4bcf-9211-598b6fcefd24\c250d7d6-b473-4ada-b8de-667da348adc1\ifc * Database version: 5507 * Database creation date: Tue Feb 21 20:02:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 20:02:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 20:02:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Pilona Telescopica Automatica:Pilona Automatica-H7508-220mm, Pilona Telescopica Automatica:Pilona Automatica-H7508-220mm:359953
In: Level 1
Type - Material: <Unnamed>, LED Rojo, Acero inoxidable, Acero galvanizado
Type - PRODUCT_PROPERTIES - 02 Material: Acero inoxidable; 03 Dimension_A: 0.22 m; 03 Dimension_H: 1.81 m; 03 Dimension_H1: 1.06 m; 03 Dimension_B: 0.274 m; 03 Dimension_C: 0.34 m; 03 Dimension_D: 0.75 m; 03 Dimension_Espesor: 0.008 m; 04 Descripción: Pilona automática fabricada con émbolo de acero inoxidable AISI-304 satinado de Ø220 x 750 mm de altura; 05 Información_Adicional: Tiene un consumo de 600W y una potencia Motor 300 W (3000r.p.m) con grado de Protección IP 67. El tiempo de subida / bajada es de 4seg; 06 Referencia: H7508; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/regulacion-accesos/telescopica-automatica-%C3%98220-x-750mm--H7508.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-H7508; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Pilona Telescopica Automatica: Pilona Automatica-H7508-220mm
