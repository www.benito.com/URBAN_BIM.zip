Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-22T12:41:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Apr 22 12:41:57 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\73d5739e-b3eb-4058-a433-023bcbc49a04\fc5126ca-1b55-4cef-9f61-5ed6f2943fa0\ifc * Database version: 5507 * Database creation date: Sat Apr 22 12:41:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Apr 22 12:41:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Apr 22 12:41:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Valla Reb:Valla Reb-VRV480-2500mm, Valla Reb:Valla Reb-VRV480-2500mm:963620
In: Level 1
Type - Material: Rebnew
Type - PRODUCT_PROPERTIES - 02 Material: Rebnew; 03 Dimension_A: 2.5 m; 03 Dimension_H: 1.5 m; 03 Dimension_H1: 0.8 m; 03 Dimension_D: 0.12 m; 04 Descripción: Valla fabricada en plástico 100% reciclado ReBnew. Se trata de un material fabricado con envases recuperados de la fracción amarilla de la recogida selectiva, que no requiere ningún tipo de mantenimiento más allá del propio de limpieza; 05 Información_Adicional: La instalación se realiza por empotramiendo, siendo recomendado un pequeño dado de hormigón en cada poste.; 06 Referencia: VRV480; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/vallas/reb--VRV480.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VRV480; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Valla Reb: Valla Reb-VRV480-2500mm
