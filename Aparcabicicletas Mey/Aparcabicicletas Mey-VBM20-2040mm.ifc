Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-02-20T18:06:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220112_1230(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 20 18:06:53 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\fc1c15df-8168-4287-8f9f-ef40e5aa7aec\82e6f639-8606-4c06-bc03-6fb6c3857769\ifc * Database version: 5507 * Database creation date: Mon Feb 20 18:06:50 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 20 18:06:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 20 18:06:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Aparcabicicletas Mey:Aparcabicicletas Mey-VBM20-2040mm, Aparcabicicletas Mey:Aparcabicicletas Mey-VBM20-2040mm:264605
In: Level 1
Type - Material: Acero
Type - PRODUCT_PROPERTIES - 02 Material: Acero; 03 Dimension_A: 2.04 m; 03 Dimension_H: 0.425 m; 03 Dimension_B: 0.435 m; 04 Descripción: Aparcabicis fabricado en acero con tratamiento Ferrus, un proceso protector del hierro, que garantiza una óptima resistencia a la corrosión.; 05 Información_Adicional: Anclaje recomendado: Mediante 4 pernos de expansión M8, según superficie y proyecto.; 06 Referencia: VBM20; 07 URL_Producto: https://www.benito.com/es/mobiliario-urbano/aparcabicicletas/mey--VBM20.html; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-VBM20; 09 Fabricante: BENITO URBAN SL
PRODUCT_PROPERTIES - 01 Producto: Aparcabicicletas Mey: Aparcabicicletas Mey-VBM20-2040mm
